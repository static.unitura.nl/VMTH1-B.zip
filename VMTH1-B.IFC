Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (2)\R&D\Producttekeningen\2. HOUTBETON VOORZIENINGEN (wood concrete)\VLEERMUIS EXTERN (bat boxes external)\VMTH1\VMTH1 brontekeningen\VMTH1-B.IFC
Time: 2026-01-28T16:09:15+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
